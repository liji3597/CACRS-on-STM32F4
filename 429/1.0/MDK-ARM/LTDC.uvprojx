# Keil uVision project LTDC.uvprojx, settings and files
target LTDC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LTDC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  ..\MQTT;  ..\Drivers\CMSIS\DSP\Include;  ..\Core\mpu;  ..\Core\mpu\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: callback.c delay.c lcd_rgb.c lcd_fonts.c dht11.c ads1292.c UI.c ecg_fir.c ecg_ana.c main.c gpio.c adc.c dma2d.c fmc.c ltdc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/mpu/: mpu6050.c mpuiic.c
    ../Core/mpu/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group MQTT
    ../MQTT/: esp8266_mqtt.c esp8266_at.c
software components: CMSIS:CORE 4.3.0
